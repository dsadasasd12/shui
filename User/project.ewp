# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32E230x8 GD GD32E230x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: GD32E230
  ICCARM.CCIncludePath2: D:\IAR\arm\CMSIS\Core\Include; C:\Users\26490\Desktop\shuizhunyi\IAR\IAR_GD3223x_fu\HW\Include; C:\Users\26490\Desktop\shuizhunyi\IAR\IAR_GD3223x_fu\LIB\Include; C:\Users\26490\Desktop\shuizhunyi\IAR\IAR_GD3223x_fu\User; C:\Users\26490\Desktop\shuizhunyi\IAR\IAR_GD3223x_fu\CMSIS\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32E230x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../CMSIS/Source/: gd32e230c_eval.c startup_gd32e23x.s system_gd32e23x.c
  group HW
    ../HW/Source/: adc.c bf2460.c ccd.c ccd_decode.c ccd_fun.c flash.c gd32e23x_it.c HZ.c lcd160642.c spi.c systick.c uart.c ui.c
  group LIB
    ../LIB/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group USER
    ./: main.c
